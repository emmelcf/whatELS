#include "Config.h"
#include "Axis.h"
#include <LittleFS.h>
#include "Debug.h"

// Variable Definitions
int ENCODER_PPR = DEFAULT_ENCODER_PPR;
int ENCODER_BACKLASH = DEFAULT_ENCODER_BACKLASH;
int AXIS_ENCODER_BACKLASH = DEFAULT_AXIS_ENCODER_BACKLASH;

long SCREW_Z_DU = DEFAULT_SCREW_Z_DU;
long MOTOR_STEPS_Z = DEFAULT_MOTOR_STEPS_Z;
long SPEED_START_Z = DEFAULT_SPEED_START_Z;
long ACCELERATION_Z = DEFAULT_ACCELERATION_Z;
long SPEED_MANUAL_MOVE_Z = DEFAULT_SPEED_MANUAL_MOVE_Z;
bool INVERT_Z = DEFAULT_INVERT_Z;
bool INVERT_Z_ENABLE = DEFAULT_INVERT_Z_ENABLE;
bool NEEDS_REST_Z = DEFAULT_NEEDS_REST_Z;
long MAX_TRAVEL_MM_Z = DEFAULT_MAX_TRAVEL_MM_Z;
long BACKLASH_DU_Z = DEFAULT_BACKLASH_DU_Z;

long SCREW_X_DU = DEFAULT_SCREW_X_DU;
long MOTOR_STEPS_X = DEFAULT_MOTOR_STEPS_X;
long SPEED_START_X = DEFAULT_SPEED_START_X;
long ACCELERATION_X = DEFAULT_ACCELERATION_X;
long SPEED_MANUAL_MOVE_X = DEFAULT_SPEED_MANUAL_MOVE_X;
bool INVERT_X = DEFAULT_INVERT_X;
bool INVERT_X_ENABLE = DEFAULT_INVERT_X_ENABLE;
bool NEEDS_REST_X = DEFAULT_NEEDS_REST_X;
long MAX_TRAVEL_MM_X = DEFAULT_MAX_TRAVEL_MM_X;
long BACKLASH_DU_X = DEFAULT_BACKLASH_DU_X;

long STEP_TIME_MS = DEFAULT_STEP_TIME_MS;
long DELAY_BETWEEN_STEPS_MS = DEFAULT_DELAY_BETWEEN_STEPS_MS;
bool ENABLE_CONTINUOUS_MOVE = DEFAULT_ENABLE_CONTINUOUS_MOVE;

bool WIFI_ENABLED = DEFAULT_WIFI_ENABLED;
String WIFI_SSID = DEFAULT_WIFI_SSID;
String WIFI_PASSWORD = DEFAULT_WIFI_PASSWORD;
String WIFI_HOSTNAME = DEFAULT_WIFI_HOSTNAME;

bool ACTIVE_Y = DEFAULT_ACTIVE_Y;
bool ROTARY_Y = DEFAULT_ROTARY_Y;
long MOTOR_STEPS_Y = DEFAULT_MOTOR_STEPS_Y;
long SCREW_Y_DU = DEFAULT_SCREW_Y_DU;
long SPEED_START_Y = DEFAULT_SPEED_START_Y;
long ACCELERATION_Y = DEFAULT_ACCELERATION_Y;
long SPEED_MANUAL_MOVE_Y = DEFAULT_SPEED_MANUAL_MOVE_Y;
bool INVERT_Y = DEFAULT_INVERT_Y;
bool INVERT_Y_ENABLE = DEFAULT_INVERT_Y_ENABLE;
bool NEEDS_REST_Y = DEFAULT_NEEDS_REST_Y;
long MAX_TRAVEL_MM_Y = DEFAULT_MAX_TRAVEL_MM_Y;
long BACKLASH_DU_Y = DEFAULT_BACKLASH_DU_Y;

float PULSE_PER_REVOLUTION_Z = DEFAULT_PULSE_PER_REVOLUTION_Z;
float PULSE_PER_REVOLUTION_X = DEFAULT_PULSE_PER_REVOLUTION_X;
float PULSE_PER_REVOLUTION_Y = DEFAULT_PULSE_PER_REVOLUTION_Y;

bool JOYSTICK_ENABLED = DEFAULT_JOYSTICK_ENABLED;
bool JOYSTICK_Z_ENABLED = DEFAULT_JOYSTICK_Z_ENABLED;
bool JOYSTICK_X_ENABLED = DEFAULT_JOYSTICK_X_ENABLED;
bool JOYSTICK_Y_ENABLED = DEFAULT_JOYSTICK_Y_ENABLED;
bool JOYSTICK_BUTTON_TOGGLES_ON_OFF = DEFAULT_JOYSTICK_BUTTON_TOGGLES_ON_OFF;
int JOYSTICK_CENTER_SAMPLES = DEFAULT_JOYSTICK_CENTER_SAMPLES;
int JOYSTICK_OVERSAMPLES = DEFAULT_JOYSTICK_OVERSAMPLES;
int JOYSTICK_SAMPLE_INTERVAL_MS = DEFAULT_JOYSTICK_SAMPLE_INTERVAL_MS;
int JOYSTICK_ADC_MAX = DEFAULT_JOYSTICK_ADC_MAX;
int JOYSTICK_DEADBAND = DEFAULT_JOYSTICK_DEADBAND;
int JOYSTICK_PULSE_QUEUE_LIMIT = DEFAULT_JOYSTICK_PULSE_QUEUE_LIMIT;
float JOYSTICK_NORMAL_REVOLUTIONS_PER_SECOND = DEFAULT_JOYSTICK_NORMAL_REVOLUTIONS_PER_SECOND;
float JOYSTICK_RAPID_REVOLUTIONS_PER_SECOND = DEFAULT_JOYSTICK_RAPID_REVOLUTIONS_PER_SECOND;
bool INVERT_JOYSTICK_Z = DEFAULT_INVERT_JOYSTICK_Z;
bool INVERT_JOYSTICK_X = DEFAULT_INVERT_JOYSTICK_X;
bool INVERT_JOYSTICK_Y = DEFAULT_INVERT_JOYSTICK_Y;
bool INVERT_JOYSTICK_BUTTON = DEFAULT_INVERT_JOYSTICK_BUTTON;

int ENCODER_STEPS_INT = DEFAULT_ENCODER_PPR * 2;
float ENCODER_STEPS_FLOAT = DEFAULT_ENCODER_PPR * 2;
long RPM_BULK = DEFAULT_ENCODER_PPR * 2;
long SAFE_DISTANCE_DU = DEFAULT_SAFE_DISTANCE_DU;
long SLOT_LEFT_REDUCTION_DU = DEFAULT_SLOT_LEFT_REDUCTION_DU;

bool SHOW_KEY_PRESSES = false;

// DRO variables
bool zDisplayModeDRO = false;
bool xDisplayModeDRO = false;
bool isDiameterMode = true;
bool isAbsoluteMode = true;
bool savedZDisplayModeDRO = false;
bool savedXDisplayModeDRO = false;
bool savedIsDiameterMode = true;
bool savedIsAbsoluteMode = true;
float xScaleIncrementalOffset = 0.0f;
float zScaleIncrementalOffset = 0.0f;
NumpadMode numpadEntryMode = PITCH;

KeyboardBinding keyboardBindings[] = {
  KEY_BINDING("left", "Left", B_LEFT),
  KEY_BINDING("right", "Right", B_RIGHT),
  KEY_BINDING("up", "Up", B_UP),
  KEY_BINDING("down", "Down", B_DOWN),
  KEY_BINDING("forward", "Y forward", B_FORWARD),
  KEY_BINDING("back", "Y back", B_BACK),
  KEY_BINDING("minus", "Minus", B_MINUS),
  KEY_BINDING("plus", "Plus", B_PLUS),
  KEY_BINDING("on", "On / start", B_ON),
  KEY_BINDING("off", "Off / stop", B_OFF),
  KEY_BINDING("stopL", "Set Z left stop", B_STOPL),
  KEY_BINDING("stopR", "Set Z right stop", B_STOPR),
  KEY_BINDING("stopU", "Set X forward stop", B_STOPU),
  KEY_BINDING("stopD", "Set X rear stop", B_STOPD),
  KEY_BINDING("stopF", "Set Y forward stop", B_STOPF),
  KEY_BINDING("stopB", "Set Y back stop", B_STOPB),
  KEY_BINDING("multistart", "Multi-start", B_MULTISTART),
  KEY_BINDING("display", "Display info", B_DISPL),
  KEY_BINDING("step", "Move step", B_STEP),
  KEY_BINDING("measure", "Measure units", B_MEASURE),
  KEY_BINDING("reverse", "Reverse pitch", B_REVERSE),
  KEY_BINDING("diameter", "Set diameter", B_DIAMETER),
  KEY_BINDING("digit0", "Digit 0", B_0),
  KEY_BINDING("digit1", "Digit 1", B_1),
  KEY_BINDING("digit2", "Digit 2", B_2),
  KEY_BINDING("digit3", "Digit 3", B_3),
  KEY_BINDING("digit4", "Digit 4", B_4),
  KEY_BINDING("digit5", "Digit 5", B_5),
  KEY_BINDING("digit6", "Digit 6", B_6),
  KEY_BINDING("digit7", "Digit 7", B_7),
  KEY_BINDING("digit8", "Digit 8", B_8),
  KEY_BINDING("digit9", "Digit 9", B_9),
  KEY_BINDING("backspace", "Backspace", B_BACKSPACE),
  KEY_BINDING("modeGears", "Mode gearbox", B_MODE_GEARS),
  KEY_BINDING("modeTurn", "Mode turn", B_MODE_TURN),
  KEY_BINDING("modeFace", "Mode face", B_MODE_FACE),
  KEY_BINDING("modeCone", "Mode cone", B_MODE_CONE),
  KEY_BINDING("modeCut", "Mode cut", B_MODE_CUT),
  KEY_BINDING("modeThread", "Mode thread", B_MODE_THREAD),
  KEY_BINDING("modeAsync", "Mode async", B_MODE_ASYNC),
  KEY_BINDING("modeEllipse", "Mode ellipse", B_MODE_ELLIPSE),
  KEY_BINDING("modeGcode", "Mode GCode", B_MODE_GCODE),
  KEY_BINDING("modeY", "Mode Y", B_MODE_Y),
  KEY_BINDING("mode", "Mode menu", B_MODE),
  KEY_BINDING("modeJoystick", "Mode joystick", B_MODE_JOYSTICK),
  KEY_BINDING("modeXGear", "Mode X gearbox", B_MODE_XGEAR),
  KEY_BINDING("modeSlot", "Mode slot", B_MODE_SLOT),
  KEY_BINDING("zeroX", "Zero X", B_X),
  KEY_BINDING("zeroZ", "Zero Z", B_Z),
  KEY_BINDING("zeroY", "Zero Y", B_Y),
  KEY_BINDING("enableX", "Enable X", B_X_ENA),
  KEY_BINDING("enableZ", "Enable Z", B_Z_ENA),
  KEY_BINDING("enableY", "Enable Y", B_Y_ENA),
};

const int KEYBOARD_BINDING_COUNT = sizeof(keyboardBindings) / sizeof(keyboardBindings[0]);

long clampLongValue(long value, long minValue, long maxValue) {
  if (value < minValue) return minValue;
  if (value > maxValue) return maxValue;
  return value;
}

int clampIntValue(int value, int minValue, int maxValue) {
  if (value < minValue) return minValue;
  if (value > maxValue) return maxValue;
  return value;
}

float clampFloatValue(float value, float minValue, float maxValue) {
  if (value < minValue) return minValue;
  if (value > maxValue) return maxValue;
  return value;
}

void setMachineConfigDefaults() {
  ENCODER_PPR = DEFAULT_ENCODER_PPR;
  ENCODER_BACKLASH = DEFAULT_ENCODER_BACKLASH;
  AXIS_ENCODER_BACKLASH = DEFAULT_AXIS_ENCODER_BACKLASH;
  SCREW_Z_DU = DEFAULT_SCREW_Z_DU;
  MOTOR_STEPS_Z = DEFAULT_MOTOR_STEPS_Z;
  SPEED_START_Z = DEFAULT_SPEED_START_Z;
  ACCELERATION_Z = DEFAULT_ACCELERATION_Z;
  SPEED_MANUAL_MOVE_Z = DEFAULT_SPEED_MANUAL_MOVE_Z;
  INVERT_Z = DEFAULT_INVERT_Z;
  INVERT_Z_ENABLE = DEFAULT_INVERT_Z_ENABLE;
  NEEDS_REST_Z = DEFAULT_NEEDS_REST_Z;
  MAX_TRAVEL_MM_Z = DEFAULT_MAX_TRAVEL_MM_Z;
  BACKLASH_DU_Z = DEFAULT_BACKLASH_DU_Z;
  SCREW_X_DU = DEFAULT_SCREW_X_DU;
  MOTOR_STEPS_X = DEFAULT_MOTOR_STEPS_X;
  SPEED_START_X = DEFAULT_SPEED_START_X;
  ACCELERATION_X = DEFAULT_ACCELERATION_X;
  SPEED_MANUAL_MOVE_X = DEFAULT_SPEED_MANUAL_MOVE_X;
  INVERT_X = DEFAULT_INVERT_X;
  INVERT_X_ENABLE = DEFAULT_INVERT_X_ENABLE;
  NEEDS_REST_X = DEFAULT_NEEDS_REST_X;
  MAX_TRAVEL_MM_X = DEFAULT_MAX_TRAVEL_MM_X;
  BACKLASH_DU_X = DEFAULT_BACKLASH_DU_X;
  STEP_TIME_MS = DEFAULT_STEP_TIME_MS;
  DELAY_BETWEEN_STEPS_MS = DEFAULT_DELAY_BETWEEN_STEPS_MS;
  ENABLE_CONTINUOUS_MOVE = DEFAULT_ENABLE_CONTINUOUS_MOVE;
  SAFE_DISTANCE_DU = DEFAULT_SAFE_DISTANCE_DU;
  SLOT_LEFT_REDUCTION_DU = DEFAULT_SLOT_LEFT_REDUCTION_DU;
  ACTIVE_Y = DEFAULT_ACTIVE_Y;
  ROTARY_Y = DEFAULT_ROTARY_Y;
  MOTOR_STEPS_Y = DEFAULT_MOTOR_STEPS_Y;
  SCREW_Y_DU = DEFAULT_SCREW_Y_DU;
  SPEED_START_Y = DEFAULT_SPEED_START_Y;
  ACCELERATION_Y = DEFAULT_ACCELERATION_Y;
  SPEED_MANUAL_MOVE_Y = DEFAULT_SPEED_MANUAL_MOVE_Y;
  INVERT_Y = DEFAULT_INVERT_Y;
  INVERT_Y_ENABLE = DEFAULT_INVERT_Y_ENABLE;
  NEEDS_REST_Y = DEFAULT_NEEDS_REST_Y;
  MAX_TRAVEL_MM_Y = DEFAULT_MAX_TRAVEL_MM_Y;
  BACKLASH_DU_Y = DEFAULT_BACKLASH_DU_Y;
  PULSE_PER_REVOLUTION_Z = DEFAULT_PULSE_PER_REVOLUTION_Z;
  PULSE_PER_REVOLUTION_X = DEFAULT_PULSE_PER_REVOLUTION_X;
  PULSE_PER_REVOLUTION_Y = DEFAULT_PULSE_PER_REVOLUTION_Y;
  JOYSTICK_ENABLED = DEFAULT_JOYSTICK_ENABLED;
  JOYSTICK_Z_ENABLED = DEFAULT_JOYSTICK_Z_ENABLED;
  JOYSTICK_X_ENABLED = DEFAULT_JOYSTICK_X_ENABLED;
  JOYSTICK_Y_ENABLED = DEFAULT_JOYSTICK_Y_ENABLED;
  JOYSTICK_BUTTON_TOGGLES_ON_OFF = DEFAULT_JOYSTICK_BUTTON_TOGGLES_ON_OFF;
  JOYSTICK_CENTER_SAMPLES = DEFAULT_JOYSTICK_CENTER_SAMPLES;
  JOYSTICK_OVERSAMPLES = DEFAULT_JOYSTICK_OVERSAMPLES;
  JOYSTICK_SAMPLE_INTERVAL_MS = DEFAULT_JOYSTICK_SAMPLE_INTERVAL_MS;
  JOYSTICK_ADC_MAX = DEFAULT_JOYSTICK_ADC_MAX;
  JOYSTICK_DEADBAND = DEFAULT_JOYSTICK_DEADBAND;
  JOYSTICK_PULSE_QUEUE_LIMIT = DEFAULT_JOYSTICK_PULSE_QUEUE_LIMIT;
  JOYSTICK_NORMAL_REVOLUTIONS_PER_SECOND = DEFAULT_JOYSTICK_NORMAL_REVOLUTIONS_PER_SECOND;
  JOYSTICK_RAPID_REVOLUTIONS_PER_SECOND = DEFAULT_JOYSTICK_RAPID_REVOLUTIONS_PER_SECOND;
  INVERT_JOYSTICK_Z = DEFAULT_INVERT_JOYSTICK_Z;
  INVERT_JOYSTICK_X = DEFAULT_INVERT_JOYSTICK_X;
  INVERT_JOYSTICK_Y = DEFAULT_INVERT_JOYSTICK_Y;
  INVERT_JOYSTICK_BUTTON = DEFAULT_INVERT_JOYSTICK_BUTTON;
}

void applyDerivedMachineConfig() {
  ENCODER_STEPS_INT = ENCODER_PPR * 2;
  ENCODER_STEPS_FLOAT = ENCODER_STEPS_INT;
  RPM_BULK = ENCODER_STEPS_INT;
}

void normalizeMachineConfig() {
  ENCODER_PPR = clampIntValue(ENCODER_PPR, 1, 15000);
  ENCODER_BACKLASH = clampIntValue(ENCODER_BACKLASH, 0, 30000);
  AXIS_ENCODER_BACKLASH = clampIntValue(AXIS_ENCODER_BACKLASH, 0, 30000);
  SCREW_Z_DU = clampLongValue(SCREW_Z_DU, 1, 10000000);
  MOTOR_STEPS_Z = clampLongValue(MOTOR_STEPS_Z, 1, 1000000);
  SPEED_START_Z = clampLongValue(SPEED_START_Z, 1, 1000000);
  ACCELERATION_Z = clampLongValue(ACCELERATION_Z, 1, 100000000);
  SPEED_MANUAL_MOVE_Z = clampLongValue(SPEED_MANUAL_MOVE_Z, 1, 1000000);
  MAX_TRAVEL_MM_Z = clampLongValue(MAX_TRAVEL_MM_Z, 1, 10000);
  BACKLASH_DU_Z = clampLongValue(BACKLASH_DU_Z, 0, 10000000);
  SCREW_X_DU = clampLongValue(SCREW_X_DU, 1, 10000000);
  MOTOR_STEPS_X = clampLongValue(MOTOR_STEPS_X, 1, 1000000);
  SPEED_START_X = clampLongValue(SPEED_START_X, 1, 1000000);
  ACCELERATION_X = clampLongValue(ACCELERATION_X, 1, 100000000);
  SPEED_MANUAL_MOVE_X = clampLongValue(SPEED_MANUAL_MOVE_X, 1, 1000000);
  MAX_TRAVEL_MM_X = clampLongValue(MAX_TRAVEL_MM_X, 1, 10000);
  BACKLASH_DU_X = clampLongValue(BACKLASH_DU_X, 0, 10000000);
  STEP_TIME_MS = clampLongValue(STEP_TIME_MS, 1, 10000);
  DELAY_BETWEEN_STEPS_MS = clampLongValue(DELAY_BETWEEN_STEPS_MS, 0, 10000);
  SAFE_DISTANCE_DU = clampLongValue(SAFE_DISTANCE_DU, 0, 10000000);
  MOTOR_STEPS_Y = clampLongValue(MOTOR_STEPS_Y, 1, 1000000);
  SCREW_Y_DU = clampLongValue(SCREW_Y_DU, 1, 10000000);
  SPEED_START_Y = clampLongValue(SPEED_START_Y, 1, 1000000);
  ACCELERATION_Y = clampLongValue(ACCELERATION_Y, 1, 100000000);
  SPEED_MANUAL_MOVE_Y = clampLongValue(SPEED_MANUAL_MOVE_Y, 1, 1000000);
  MAX_TRAVEL_MM_Y = clampLongValue(MAX_TRAVEL_MM_Y, 1, 10000);
  BACKLASH_DU_Y = clampLongValue(BACKLASH_DU_Y, 0, 10000000);
  PULSE_PER_REVOLUTION_Z = clampFloatValue(PULSE_PER_REVOLUTION_Z, 1.0, 100000.0);
  PULSE_PER_REVOLUTION_X = clampFloatValue(PULSE_PER_REVOLUTION_X, 1.0, 100000.0);
  PULSE_PER_REVOLUTION_Y = clampFloatValue(PULSE_PER_REVOLUTION_Y, 1.0, 100000.0);
  JOYSTICK_CENTER_SAMPLES = clampIntValue(JOYSTICK_CENTER_SAMPLES, 1, 1024);
  JOYSTICK_OVERSAMPLES = clampIntValue(JOYSTICK_OVERSAMPLES, 1, 1024);
  JOYSTICK_SAMPLE_INTERVAL_MS = clampIntValue(JOYSTICK_SAMPLE_INTERVAL_MS, 1, 1000);
  JOYSTICK_ADC_MAX = clampIntValue(JOYSTICK_ADC_MAX, 1, 65535);
  JOYSTICK_DEADBAND = clampIntValue(JOYSTICK_DEADBAND, 0, JOYSTICK_ADC_MAX - 1);
  JOYSTICK_PULSE_QUEUE_LIMIT = clampIntValue(JOYSTICK_PULSE_QUEUE_LIMIT, 1, 1000000);
  JOYSTICK_NORMAL_REVOLUTIONS_PER_SECOND = clampFloatValue(JOYSTICK_NORMAL_REVOLUTIONS_PER_SECOND, 0.01, 1000.0);
  JOYSTICK_RAPID_REVOLUTIONS_PER_SECOND = clampFloatValue(JOYSTICK_RAPID_REVOLUTIONS_PER_SECOND, 0.01, 1000.0);
  SLOT_LEFT_REDUCTION_DU = clampLongValue(SLOT_LEFT_REDUCTION_DU, 0, 10000000);
  if (SPEED_START_Z > SPEED_MANUAL_MOVE_Z) SPEED_START_Z = SPEED_MANUAL_MOVE_Z;
  if (SPEED_START_X > SPEED_MANUAL_MOVE_X) SPEED_START_X = SPEED_MANUAL_MOVE_X;
  if (SPEED_START_Y > SPEED_MANUAL_MOVE_Y) SPEED_START_Y = SPEED_MANUAL_MOVE_Y;
  applyDerivedMachineConfig();
}

void loadMachineConfig() {
  DEBUG_PRINTLN("setMachineConfigDefaults...");
  setMachineConfigDefaults();
  Preferences cfg;
  DEBUG_PRINTLN("cfg.begin...");
  cfg.begin(CONFIG_NAMESPACE);
  DEBUG_PRINTLN("cfg.getInt...");
  if (cfg.getInt(CFG_VERSION) != CONFIG_VERSION) {
    DEBUG_PRINTLN("cfg.clear()...");
    cfg.clear();
    DEBUG_PRINTLN("cfg.putInt...");
    cfg.putInt(CFG_VERSION, CONFIG_VERSION);
  }
  DEBUG_PRINTLN("loading fields...");
  ENCODER_PPR = cfg.getInt(CFG_ENCODER_PPR, ENCODER_PPR);
  ENCODER_BACKLASH = cfg.getInt(CFG_ENCODER_BACKLASH, ENCODER_BACKLASH);
  AXIS_ENCODER_BACKLASH = cfg.getInt(CFG_AXIS_ENCODER_BACKLASH, AXIS_ENCODER_BACKLASH);
  SCREW_Z_DU = cfg.getLong(CFG_SCREW_Z_DU, SCREW_Z_DU);
  MOTOR_STEPS_Z = cfg.getLong(CFG_MOTOR_STEPS_Z, MOTOR_STEPS_Z);
  SPEED_START_Z = cfg.getLong(CFG_SPEED_START_Z, SPEED_START_Z);
  ACCELERATION_Z = cfg.getLong(CFG_ACCELERATION_Z, ACCELERATION_Z);
  SPEED_MANUAL_MOVE_Z = cfg.getLong(CFG_SPEED_MANUAL_MOVE_Z, SPEED_MANUAL_MOVE_Z);
  INVERT_Z = cfg.getBool(CFG_INVERT_Z, INVERT_Z);
  INVERT_Z_ENABLE = cfg.getBool(CFG_INVERT_Z_ENABLE, INVERT_Z_ENABLE);
  NEEDS_REST_Z = cfg.getBool(CFG_NEEDS_REST_Z, NEEDS_REST_Z);
  MAX_TRAVEL_MM_Z = cfg.getLong(CFG_MAX_TRAVEL_MM_Z, MAX_TRAVEL_MM_Z);
  BACKLASH_DU_Z = cfg.getLong(CFG_BACKLASH_DU_Z, BACKLASH_DU_Z);
  SCREW_X_DU = cfg.getLong(CFG_SCREW_X_DU, SCREW_X_DU);
  MOTOR_STEPS_X = cfg.getLong(CFG_MOTOR_STEPS_X, MOTOR_STEPS_X);
  SPEED_START_X = cfg.getLong(CFG_SPEED_START_X, SPEED_START_X);
  ACCELERATION_X = cfg.getLong(CFG_ACCELERATION_X, ACCELERATION_X);
  SPEED_MANUAL_MOVE_X = cfg.getLong(CFG_SPEED_MANUAL_MOVE_X, SPEED_MANUAL_MOVE_X);
  INVERT_X = cfg.getBool(CFG_INVERT_X, INVERT_X);
  INVERT_X_ENABLE = cfg.getBool(CFG_INVERT_X_ENABLE, INVERT_X_ENABLE);
  NEEDS_REST_X = cfg.getBool(CFG_NEEDS_REST_X, NEEDS_REST_X);
  MAX_TRAVEL_MM_X = cfg.getLong(CFG_MAX_TRAVEL_MM_X, MAX_TRAVEL_MM_X);
  BACKLASH_DU_X = cfg.getLong(CFG_BACKLASH_DU_X, BACKLASH_DU_X);
  STEP_TIME_MS = cfg.getLong(CFG_STEP_TIME_MS, STEP_TIME_MS);
  DELAY_BETWEEN_STEPS_MS = cfg.getLong(CFG_DELAY_BETWEEN_STEPS_MS, DELAY_BETWEEN_STEPS_MS);
  ENABLE_CONTINUOUS_MOVE = cfg.getBool(CFG_ENABLE_CONTINUOUS_MOVE, ENABLE_CONTINUOUS_MOVE);
  SAFE_DISTANCE_DU = cfg.getLong(CFG_SAFE_DISTANCE_DU, SAFE_DISTANCE_DU);
  SLOT_LEFT_REDUCTION_DU = cfg.getLong(CFG_SLOT_LEFT_REDUCTION_DU, SLOT_LEFT_REDUCTION_DU);
  ACTIVE_Y = cfg.getBool(CFG_ACTIVE_Y, ACTIVE_Y);
  ROTARY_Y = cfg.getBool(CFG_ROTARY_Y, ROTARY_Y);
  MOTOR_STEPS_Y = cfg.getLong(CFG_MOTOR_STEPS_Y, MOTOR_STEPS_Y);
  SCREW_Y_DU = cfg.getLong(CFG_SCREW_Y_DU, SCREW_Y_DU);
  SPEED_START_Y = cfg.getLong(CFG_SPEED_START_Y, SPEED_START_Y);
  ACCELERATION_Y = cfg.getLong(CFG_ACCELERATION_Y, ACCELERATION_Y);
  SPEED_MANUAL_MOVE_Y = cfg.getLong(CFG_SPEED_MANUAL_MOVE_Y, SPEED_MANUAL_MOVE_Y);
  INVERT_Y = cfg.getBool(CFG_INVERT_Y, INVERT_Y);
  INVERT_Y_ENABLE = cfg.getBool(CFG_INVERT_Y_ENABLE, INVERT_Y_ENABLE);
  NEEDS_REST_Y = cfg.getBool(CFG_NEEDS_REST_Y, NEEDS_REST_Y);
  MAX_TRAVEL_MM_Y = cfg.getLong(CFG_MAX_TRAVEL_MM_Y, MAX_TRAVEL_MM_Y);
  BACKLASH_DU_Y = cfg.getLong(CFG_BACKLASH_DU_Y, BACKLASH_DU_Y);
  float legacyPulsePerRevolution = cfg.getFloat(CFG_PULSE_PER_REVOLUTION, -1.0);
  PULSE_PER_REVOLUTION_Z = cfg.getFloat(CFG_PULSE_PER_REVOLUTION_Z, legacyPulsePerRevolution >= 1.0 ? legacyPulsePerRevolution : PULSE_PER_REVOLUTION_Z);
  PULSE_PER_REVOLUTION_X = cfg.getFloat(CFG_PULSE_PER_REVOLUTION_X, legacyPulsePerRevolution >= 1.0 ? legacyPulsePerRevolution : PULSE_PER_REVOLUTION_X);
  PULSE_PER_REVOLUTION_Y = cfg.getFloat(CFG_PULSE_PER_REVOLUTION_Y, legacyPulsePerRevolution >= 1.0 ? legacyPulsePerRevolution : PULSE_PER_REVOLUTION_Y);
  JOYSTICK_ENABLED = cfg.getBool(CFG_JOYSTICK_ENABLED, JOYSTICK_ENABLED);
  JOYSTICK_Z_ENABLED = cfg.getBool(CFG_JOYSTICK_Z_ENABLED, JOYSTICK_Z_ENABLED);
  JOYSTICK_X_ENABLED = cfg.getBool(CFG_JOYSTICK_X_ENABLED, JOYSTICK_X_ENABLED);
  JOYSTICK_Y_ENABLED = cfg.getBool(CFG_JOYSTICK_Y_ENABLED, JOYSTICK_Y_ENABLED);
  JOYSTICK_BUTTON_TOGGLES_ON_OFF = cfg.getBool(CFG_JOYSTICK_BUTTON_TOGGLES_ON_OFF, JOYSTICK_BUTTON_TOGGLES_ON_OFF);
  JOYSTICK_CENTER_SAMPLES = cfg.getInt(CFG_JOYSTICK_CENTER_SAMPLES, JOYSTICK_CENTER_SAMPLES);
  JOYSTICK_OVERSAMPLES = cfg.getInt(CFG_JOYSTICK_OVERSAMPLES, JOYSTICK_OVERSAMPLES);
  JOYSTICK_SAMPLE_INTERVAL_MS = cfg.getInt(CFG_JOYSTICK_SAMPLE_INTERVAL_MS, JOYSTICK_SAMPLE_INTERVAL_MS);
  JOYSTICK_ADC_MAX = cfg.getInt(CFG_JOYSTICK_ADC_MAX, JOYSTICK_ADC_MAX);
  JOYSTICK_DEADBAND = cfg.getInt(CFG_JOYSTICK_DEADBAND, JOYSTICK_DEADBAND);
  JOYSTICK_PULSE_QUEUE_LIMIT = cfg.getInt(CFG_JOYSTICK_PULSE_QUEUE_LIMIT, JOYSTICK_PULSE_QUEUE_LIMIT);
  JOYSTICK_NORMAL_REVOLUTIONS_PER_SECOND = cfg.getFloat(CFG_JOYSTICK_NORMAL_RPS, JOYSTICK_NORMAL_REVOLUTIONS_PER_SECOND);
  JOYSTICK_RAPID_REVOLUTIONS_PER_SECOND = cfg.getFloat(CFG_JOYSTICK_RAPID_RPS, JOYSTICK_RAPID_REVOLUTIONS_PER_SECOND);
  INVERT_JOYSTICK_Z = cfg.getBool(CFG_INVERT_JOYSTICK_Z, INVERT_JOYSTICK_Z);
  INVERT_JOYSTICK_X = cfg.getBool(CFG_INVERT_JOYSTICK_X, INVERT_JOYSTICK_X);
  INVERT_JOYSTICK_Y = cfg.getBool(CFG_INVERT_JOYSTICK_Y, INVERT_JOYSTICK_Y);
  INVERT_JOYSTICK_BUTTON = cfg.getBool(CFG_INVERT_JOYSTICK_BUTTON, INVERT_JOYSTICK_BUTTON);
  cfg.end();
  normalizeMachineConfig();
}

void saveMachineConfig() {
  normalizeMachineConfig();
  Preferences cfg;
  cfg.begin(CONFIG_NAMESPACE);
  cfg.putInt(CFG_VERSION, CONFIG_VERSION);
  cfg.putInt(CFG_ENCODER_PPR, ENCODER_PPR);
  cfg.putInt(CFG_ENCODER_BACKLASH, ENCODER_BACKLASH);
  cfg.putInt(CFG_AXIS_ENCODER_BACKLASH, AXIS_ENCODER_BACKLASH);
  cfg.putLong(CFG_SCREW_Z_DU, SCREW_Z_DU);
  cfg.putLong(CFG_MOTOR_STEPS_Z, MOTOR_STEPS_Z);
  cfg.putLong(CFG_SPEED_START_Z, SPEED_START_Z);
  cfg.putLong(CFG_ACCELERATION_Z, ACCELERATION_Z);
  cfg.putLong(CFG_SPEED_MANUAL_MOVE_Z, SPEED_MANUAL_MOVE_Z);
  cfg.putBool(CFG_INVERT_Z, INVERT_Z);
  cfg.putBool(CFG_INVERT_Z_ENABLE, INVERT_Z_ENABLE);
  cfg.putBool(CFG_NEEDS_REST_Z, NEEDS_REST_Z);
  cfg.putLong(CFG_MAX_TRAVEL_MM_Z, MAX_TRAVEL_MM_Z);
  cfg.putLong(CFG_BACKLASH_DU_Z, BACKLASH_DU_Z);
  cfg.putLong(CFG_SCREW_X_DU, SCREW_X_DU);
  cfg.putLong(CFG_MOTOR_STEPS_X, MOTOR_STEPS_X);
  cfg.putLong(CFG_SPEED_START_X, SPEED_START_X);
  cfg.putLong(CFG_ACCELERATION_X, ACCELERATION_X);
  cfg.putLong(CFG_SPEED_MANUAL_MOVE_X, SPEED_MANUAL_MOVE_X);
  cfg.putBool(CFG_INVERT_X, INVERT_X);
  cfg.putBool(CFG_INVERT_X_ENABLE, INVERT_X_ENABLE);
  cfg.putBool(CFG_NEEDS_REST_X, NEEDS_REST_X);
  cfg.putLong(CFG_MAX_TRAVEL_MM_X, MAX_TRAVEL_MM_X);
  cfg.putLong(CFG_BACKLASH_DU_X, BACKLASH_DU_X);
  cfg.putLong(CFG_STEP_TIME_MS, STEP_TIME_MS);
  cfg.putLong(CFG_DELAY_BETWEEN_STEPS_MS, DELAY_BETWEEN_STEPS_MS);
  cfg.putBool(CFG_ENABLE_CONTINUOUS_MOVE, ENABLE_CONTINUOUS_MOVE);
  cfg.putLong(CFG_SAFE_DISTANCE_DU, SAFE_DISTANCE_DU);
  cfg.putLong(CFG_SLOT_LEFT_REDUCTION_DU, SLOT_LEFT_REDUCTION_DU);
  cfg.putBool(CFG_ACTIVE_Y, ACTIVE_Y);
  cfg.putBool(CFG_ROTARY_Y, ROTARY_Y);
  cfg.putLong(CFG_MOTOR_STEPS_Y, MOTOR_STEPS_Y);
  cfg.putLong(CFG_SCREW_Y_DU, SCREW_Y_DU);
  cfg.putLong(CFG_SPEED_START_Y, SPEED_START_Y);
  cfg.putLong(CFG_ACCELERATION_Y, ACCELERATION_Y);
  cfg.putLong(CFG_SPEED_MANUAL_MOVE_Y, SPEED_MANUAL_MOVE_Y);
  cfg.putBool(CFG_INVERT_Y, INVERT_Y);
  cfg.putBool(CFG_INVERT_Y_ENABLE, INVERT_Y_ENABLE);
  cfg.putBool(CFG_NEEDS_REST_Y, NEEDS_REST_Y);
  cfg.putLong(CFG_MAX_TRAVEL_MM_Y, MAX_TRAVEL_MM_Y);
  cfg.putLong(CFG_BACKLASH_DU_Y, BACKLASH_DU_Y);
  cfg.putFloat(CFG_PULSE_PER_REVOLUTION_Z, PULSE_PER_REVOLUTION_Z);
  cfg.putFloat(CFG_PULSE_PER_REVOLUTION_X, PULSE_PER_REVOLUTION_X);
  cfg.putFloat(CFG_PULSE_PER_REVOLUTION_Y, PULSE_PER_REVOLUTION_Y);
  cfg.putBool(CFG_JOYSTICK_ENABLED, JOYSTICK_ENABLED);
  cfg.putBool(CFG_JOYSTICK_Z_ENABLED, JOYSTICK_Z_ENABLED);
  cfg.putBool(CFG_JOYSTICK_X_ENABLED, JOYSTICK_X_ENABLED);
  cfg.putBool(CFG_JOYSTICK_Y_ENABLED, JOYSTICK_Y_ENABLED);
  cfg.putBool(CFG_JOYSTICK_BUTTON_TOGGLES_ON_OFF, JOYSTICK_BUTTON_TOGGLES_ON_OFF);
  cfg.putInt(CFG_JOYSTICK_CENTER_SAMPLES, JOYSTICK_CENTER_SAMPLES);
  cfg.putInt(CFG_JOYSTICK_OVERSAMPLES, JOYSTICK_OVERSAMPLES);
  cfg.putInt(CFG_JOYSTICK_SAMPLE_INTERVAL_MS, JOYSTICK_SAMPLE_INTERVAL_MS);
  cfg.putInt(CFG_JOYSTICK_ADC_MAX, JOYSTICK_ADC_MAX);
  cfg.putInt(CFG_JOYSTICK_DEADBAND, JOYSTICK_DEADBAND);
  cfg.putInt(CFG_JOYSTICK_PULSE_QUEUE_LIMIT, JOYSTICK_PULSE_QUEUE_LIMIT);
  cfg.putFloat(CFG_JOYSTICK_NORMAL_RPS, JOYSTICK_NORMAL_REVOLUTIONS_PER_SECOND);
  cfg.putFloat(CFG_JOYSTICK_RAPID_RPS, JOYSTICK_RAPID_REVOLUTIONS_PER_SECOND);
  cfg.putBool(CFG_INVERT_JOYSTICK_Z, INVERT_JOYSTICK_Z);
  cfg.putBool(CFG_INVERT_JOYSTICK_X, INVERT_JOYSTICK_X);
  cfg.putBool(CFG_INVERT_JOYSTICK_Y, INVERT_JOYSTICK_Y);
  cfg.putBool(CFG_INVERT_JOYSTICK_BUTTON, INVERT_JOYSTICK_BUTTON);
  cfg.end();
}

void setKeyboardConfigDefaults() {
  SHOW_KEY_PRESSES = false;
  for (int i = 0; i < KEYBOARD_BINDING_COUNT; i++) {
    keyboardBindings[i].code = keyboardBindings[i].defaultCode;
  }
}

const char* keyboardActionLabel(byte actionCode) {
  for (int i = 0; i < KEYBOARD_BINDING_COUNT; i++) {
    if (keyboardBindings[i].actionCode == actionCode) {
      return keyboardBindings[i].label;
    }
  }
  return "Unmapped";
}

byte keyboardActionForCode(byte physicalCode) {
  for (int i = 0; i < KEYBOARD_BINDING_COUNT; i++) {
    if (keyboardBindings[i].code == physicalCode) {
      return keyboardBindings[i].actionCode;
    }
  }
  return 0;
}

bool validateKeyboardConfig(String* error) {
  for (int i = 0; i < KEYBOARD_BINDING_COUNT; i++) {
    if (keyboardBindings[i].code == 0) {
      *error = String(keyboardBindings[i].label) + " must use key code 1..255";
      return false;
    }
    if (keyboardBindings[i].code == 170) {
      *error = String(keyboardBindings[i].label) + " cannot use reserved keyboard code 170";
      return false;
    }
    for (int j = i + 1; j < KEYBOARD_BINDING_COUNT; j++) {
      if (keyboardBindings[i].code == keyboardBindings[j].code) {
        *error = String("Key code ") + String(keyboardBindings[i].code) + " is assigned to both " + keyboardBindings[i].label + " and " + keyboardBindings[j].label;
        return false;
      }
    }
  }
  return true;
}

void saveKeyboardConfig() {
  Preferences cfg;
  cfg.begin(KEYBOARD_CONFIG_NAMESPACE);
  cfg.putInt(KCFG_VERSION, KEYBOARD_CONFIG_VERSION);
  cfg.putBool(KCFG_SHOW_KEY_PRESSES, SHOW_KEY_PRESSES);
  for (int i = 0; i < KEYBOARD_BINDING_COUNT; i++) {
    cfg.putUChar(keyboardBindings[i].id, keyboardBindings[i].code);
  }
  cfg.end();
}

void loadKeyboardConfig() {
  setKeyboardConfigDefaults();
  Preferences cfg;
  cfg.begin(KEYBOARD_CONFIG_NAMESPACE);
  if (cfg.getInt(KCFG_VERSION) != KEYBOARD_CONFIG_VERSION) {
    cfg.clear();
    cfg.putInt(KCFG_VERSION, KEYBOARD_CONFIG_VERSION);
  }
  SHOW_KEY_PRESSES = cfg.getBool(KCFG_SHOW_KEY_PRESSES, SHOW_KEY_PRESSES);
  for (int i = 0; i < KEYBOARD_BINDING_COUNT; i++) {
    keyboardBindings[i].code = cfg.getUChar(keyboardBindings[i].id, keyboardBindings[i].code);
  }
  cfg.end();

  String error = "";
  if (!validateKeyboardConfig(&error)) {
    setKeyboardConfigDefaults();
    saveKeyboardConfig();
  }
  DEBUG_PRINTLN("Finished loadKeyboardConfig");
}

void setWifiConfigDefaults() {
  WIFI_ENABLED = DEFAULT_WIFI_ENABLED;
  WIFI_SSID = DEFAULT_WIFI_SSID;
  WIFI_PASSWORD = DEFAULT_WIFI_PASSWORD;
  WIFI_HOSTNAME = DEFAULT_WIFI_HOSTNAME;
}

bool validateWifiConfig(String* error) {
  if (WIFI_SSID.length() > 32) {
    *error = "wifiSsid must be 32 characters or less";
    return false;
  }
  if (WIFI_PASSWORD.length() > 63) {
    *error = "wifiPassword must be 63 characters or less";
    return false;
  }
  if (WIFI_PASSWORD.length() > 0 && WIFI_PASSWORD.length() < 8) {
    *error = "wifiPassword must be empty or at least 8 characters";
    return false;
  }
  return true;
}

void loadWifiConfig() {
  setWifiConfigDefaults();
  Preferences cfg;
  cfg.begin(WIFI_CONFIG_NAMESPACE);
  if (cfg.getInt(WCFG_VERSION) != WIFI_CONFIG_VERSION) {
    cfg.clear();
    cfg.putInt(WCFG_VERSION, WIFI_CONFIG_VERSION);
  }
  WIFI_ENABLED = cfg.getBool(WCFG_ENABLED, WIFI_ENABLED);
  WIFI_SSID = cfg.getString(WCFG_SSID, WIFI_SSID);
  WIFI_PASSWORD = cfg.getString(WCFG_PASSWORD, WIFI_PASSWORD);
  WIFI_HOSTNAME = cfg.getString(WCFG_HOSTNAME, WIFI_HOSTNAME);
  cfg.end();

  String error = "";
  if (!validateWifiConfig(&error)) {
    setWifiConfigDefaults();
  }
}

void saveWifiConfig() {
  Preferences cfg;
  cfg.begin(WIFI_CONFIG_NAMESPACE);
  cfg.putInt(WCFG_VERSION, WIFI_CONFIG_VERSION);
  cfg.putBool(WCFG_ENABLED, WIFI_ENABLED);
  cfg.putString(WCFG_SSID, WIFI_SSID);
  cfg.putString(WCFG_PASSWORD, WIFI_PASSWORD);
  cfg.putString(WCFG_HOSTNAME, WIFI_HOSTNAME);
  cfg.end();
}

void setMeasure(int value) {
  if (measure == value) {
    return;
  }
  measure = value;
  moveStep = measure == MEASURE_METRIC ? MOVE_STEP_1 : MOVE_STEP_IMP_1;
}
